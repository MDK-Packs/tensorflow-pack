# Keil uVision project microspeech.uvprojx, settings and files
target Example (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28000000,0x00200000) IROM(0x10000000,0x00040000) IROM2(0x00000000,0x00040000) XRAM(0x38200000,0x00200000) XRAM2(0x28200000,0x00200000) XRAM3(0x31000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: Optim=7 v6Lang=3 v6LangP=6 wLevel=3
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group BSP
    ./API/Source/: serial.c
  group TF_micro_frontend
    ../micro_speech/src/microfrontend/lib/: fft.cc fft_util.cc filterbank.c filterbank_util.c frontend.c frontend_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c window.c window_util.c
  group TF_micro_features
    ../micro_speech/src/micro_features/: micro_features_generator.cc micro_model_settings.cc model.cc no_micro_features_data.cc yes_micro_features_data.cc
  group TF_main
    ../micro_speech/src/: audio_provider.cc command_responder.cc feature_provider.cc main.cc main_functions.cc recognize_commands.cc
  group TF_test
    ../micro_speech/src/: micro_speech_test.cc audio_provider_mock.cc audio_provider_mock_test.cc yes_1000ms_sample_data.cc no_1000ms_sample_data.cc
target Example Audio Provider Mock (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439
target Example Test (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=6 v6Lto=1 wLevel=3
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439
target Example Audio Provider Mock Test (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: as above
  output: microspeech +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=6 v6Lto=1 wLevel=3
  c include: ..\micro_speech\src
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x40000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --diag_suppress 6439
software components: CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.4.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:GPIO 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:SPI 1.0.0, Native Driver:SysCounter 1.0.0, Native Driver:SysTimer 1.0.0, Native Driver:UART 1.0.0, Native Driver:Watch Dog 1.0.0, Machine Learning:NPU Support:Ethos-U Driver 1.0.5, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.1.20210416, Machine Learning:TensorFlow:Kernel 0.1.20210416, Machine Learning:TensorFlow:Testing 0.1.20210416
