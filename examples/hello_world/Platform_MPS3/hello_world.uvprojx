# Keil uVision project hello_world.uvprojx, settings and files
target Example (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28000000,0x00200000) IROM(0x10000000,0x00040000) IROM2(0x00000000,0x00040000) XRAM(0x38200000,0x00200000) XRAM2(0x28200000,0x00200000) XRAM3(0x31000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: hello_world
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=6 wLevel=3
  c define: FLATBUFFERS_PREFER_PRINTF
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  group BSP
    ./API/Source/: serial.c
  group TF_main
    ../hello_world/src/: constants.cc main.cc main_functions.cc model.cc output_handler.cc
  group TF_test
    ../hello_world/src/: hello_world_test.cc
target Example Test (6160000::V6.16::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: as above
  output: hello_world
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=6 wLevel=3
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
software components: CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.4.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:GPIO 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:UART 1.0.0, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.1.20210416, Machine Learning:TensorFlow:Kernel 0.1.20210416, Machine Learning:TensorFlow:Testing 0.1.20210416
