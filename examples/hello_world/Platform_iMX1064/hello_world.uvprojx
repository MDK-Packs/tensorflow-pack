# Keil uVision project hello_world.uvprojx, settings and files
target Example (6160000::V6.16::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.13.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: hello_world
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: FLATBUFFERS_PREFER_PRINTF, SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group BSP
    ./Board_IO/: retarget_stdio.c
  group TF_main
    ../hello_world/src/: constants.cc main.cc main_functions.cc model.cc output_handler.cc
  group TF_test
    ../hello_world/src/: hello_world_test.cc
target Example Test (6160000::V6.16::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.13.0.0
  cpu: as above
  output: hello_world
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: as above
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, Compiler:I/O:STDOUT 1.2.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:CMSIS:MIMXRT1064_system 1.0.0, Device:SDK Drivers:clock 2.4.0, Device:SDK Drivers:common 2.2.9, Device:SDK Drivers:dmamux 2.0.5, Device:SDK Drivers:edma 2.4.1, Device:SDK Drivers:gpio 2.0.5, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.4.1, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:xip_board 2.0.1, Device:SDK Drivers:xip_device 2.0.2, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1064_startup 1.1.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.2.20210628, Machine Learning:TensorFlow:Kernel 0.2.20210628, Machine Learning:TensorFlow:Testing 0.2.20210628
