# Keil uVision project hello_world.Example_Test.uvprojx, settings and files
target Example_Test (ARM-ADS)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.1.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: hello_world
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=1 wLevel=3
  c misc: -Wno-documentation -Wno-documentation-unknown-command -Wno-license-management -Wno-missing-noreturn -Wno-missing-prototypes -Wno-missing-variable-declarations -Wno-nonportable-include-path -Wno-packed -Wno-parentheses-equality -Wno-reserved-id-macro -Wno-unused-macros -fno-exceptions -xc++
  memory RVCT6: ROM 0x20000000 size 0x20000
  memory RVCT7: ROM 0x20020000 size 0x20000
  memory RVCT8: ROM 0x20040000 size 0x20000
  memory RVCT9: ROM 0x0 size 0x80000
  memory RVCT10: ROM 0x1000000 size 0x200000
  scatter file: ./RTE/Device/SSE-300-MPS3/fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --summary_stderr
  group BSP
    ./API/Source/: serial.c
  group TF_main
    ../hello_world/src/: constants.cc model.cc output_handler.cc
  group TF_test
    ../hello_world/src/: hello_world_test.cc
software components: CMSIS Driver:MPC 1.0.0, CMSIS Driver:PPC 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.4.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Native Driver:GPIO 1.0.0, Native Driver:IO 1.0.0, Native Driver:MPC 1.0.0, Native Driver:PPC 1.0.0, Native Driver:UART 1.0.0, Compiler:I/O:STDOUT 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.1.20210416, Machine Learning:TensorFlow:Kernel 0.1.20210416, Machine Learning:TensorFlow:Testing 0.1.20210416
