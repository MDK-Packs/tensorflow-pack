# Keil uVision project project.uvprojx, settings and files
target Example - FVP (6140001::V6.14.1::ARMCLANG)
  device: SSE-300-MPS2 ARM
  pack: ARM.V2M_MPS2_SSE_300_BSP.1.0.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28000000,0x00200000) IROM(0x10000000,0x00040000) IROM2(0x00000000,0x00040000) XRAM(0x38200000,0x00200000) XRAM2(0x28200000,0x00200000) XRAM3(0x31000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=6 wLevel=1
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS2\fvp_sse300_mps2_s.sct
  group Source Group 1
    ./src/: constants.cc hello_world_test.cc main.cc main_functions.cc model.cc output_handler.cc output_handler_test.cc
target Hello World Test - FVP (6140001::V6.14.1::ARMCLANG)
  device: SSE-300-MPS2 ARM
  pack: ARM.V2M_MPS2_SSE_300_BSP.1.0.0
  cpu: as above
  output: project
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=6 wLevel=1
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT5: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x38200000 size 0x200000
  memory RVCT7: RAM 0x28200000 size 0x200000
  memory RVCT8: RAM 0x31000000 size 0x40000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS2\fvp_sse300_mps2_s.sct
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Native Driver:UART 1.0.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.1.20210225, Machine Learning:TensorFlow:Kernel 0.1.20210225
